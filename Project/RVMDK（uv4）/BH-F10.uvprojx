# Keil uVision project BH-F10.uvprojx, settings and files
target MPU (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\flash;..\..\User\delay;..\..\User\dht11;..\..\User\rtc;..\..\User\exti;..\..\User\SysTick;..\..\User\usart;..\..\User\calendar;..\..\User\date;..\..\User\Common;..\..\User\ESP8266;..\..\User\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/mpu6050/: mpu6050.c
    ../../User/i2c/: bsp_i2c.c
    ../../User/usart/: bsp_usart.c
    ../../User/font/: fonts.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/flash/: flash.c
    ../../User/dht11/: dht11.c
    ../../User/delay/: delay.c
    ../../User/exti/: bsp_exti.c
    ../../User/beep/: bsp_beep.c
    ../../User/calendar/: calendar.c
    ../../User/date/: date.c
    ../../User/rtc/: rtc.c
    ../../User/Key/: bsp_key.c
    ../../User/ESP8266/: bsp_esp8266_test.c bsp_esp8266.c
    ../../User/Common/: Common.c
  group DOC
    ../../Doc/: readme.txt
